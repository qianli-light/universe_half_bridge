<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\universe_half_bridge.ewp</path>
  </project>
  <batchBuild />
</workspace>
